# Keil uVision project panzer.uvprojx, settings and files
target panzer (6240000::V6.24::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: panzer +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../GetData;../Emm_V5;../Motion;../Selftest;../App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group GetData
    ../GetData/: Encode.h Encode.c PID.c PID.h interurp.h interurp.c Control_Car.c Control_Car.h protocol.c protocol.h Car_Sense.c Car_Sense.h car_config.h
  group Selftest
    ../Selftest/: selftest.c selftest.h
  group App
    ../App/: car_units.h motion_app.c motion_app.h nav_routes.c nav_routes.h nav_turntable.c nav_turntable.h nav_tracking.c nav_tracking.h car_protocol.h nav_task.c nav_task.h
  group Motion
    ../Motion/: mf_motion.c mf_path.c mf_odom.c mf_kinematics.c mf_pid.c mf_motion.h mf_path.h mf_types.h mf_config.h
  group Emm_V5
    ../Emm_V5/: Emm_V5.c Emm_V5.h
software components: CMSIS:CORE 6.1.0
